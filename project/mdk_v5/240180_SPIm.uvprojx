# Keil uVision project 240180_SPIm.uvprojx, settings and files
target P2-prototype (6210000::V6.21::ARMCLANG)
  device: -AT32F403ACCT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Dyson831-P2.axf +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe --bin -o objects/Dyson831-P2.bin objects/Dyson831-P2.axf
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\bsp\;..\at32f403a_407_board;..\iHastek\inc;..\user;..\..\libraries\timer_event;..\..\libraries\absolute_encoder
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x8400000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../user/: display.c driver.c main.c usr.c logger.c fonts.c
    ../bsp/: flash.c
  group bsp
    ../bsp/: lcd.c spi_LCD.c stepper_motor.c i2c.c sen68.c scd40.c opt3004.c encoder.c
    ../at32f403a_407_board/: at32f403a_407_board.c at32f403a_407_clock.c at32f403a_407_int.c st32f403a_407_interrupt.c
  group hal
    ../../libraries/drivers/src/: at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_crm.c at32f403a_407_wdt.c at32f403a_407_adc.c at32f403a_407_rtc.c at32f403a_407_pwc.c at32f403a_407_dma.c at32f403a_407_spi.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_tmr.c at32f403a_407_bpr.c at32f403a_407_exint.c at32f403a_407_crc.c at32f403a_407_i2c.c
  group startup
    ../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group readme
    ../: readme.txt
  group iHastek
    ../iHastek/core/: core_key.c core_tick.c platform.c core_pm25.c core_fan_speed_handle.c core_te.c core_hepa.c core_drive_flash.c core_power.c core_off_timer.c core_compile_time.c core_uart_protocol.c core_ir.c
    ../../libraries/timer_event/: TimeEvent.c
  group absolute_encoder
    ../../libraries/absolute_encoder/: absolute_encoder.c encoder_map.c input_preprocessor.c position_tracker.c smart_search_manager.c test_example.c
